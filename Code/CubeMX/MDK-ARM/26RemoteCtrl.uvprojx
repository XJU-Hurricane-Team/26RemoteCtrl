# Keil uVision project 26RemoteCtrl.uvprojx, settings and files
target 26RemoteCtrl (ARM-ADS)
  device: STM32F429VETx STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 26RemoteCtrl +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c dma.c dma2d.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp OSWrappers.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group gui
    ../touchgfx/gui/src/bluemap_screen/: bluemappresenter.cpp bluemapview.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/redmap_screen/: redmappresenter.cpp redmapview.cpp
    ../touchgfx/gui/src/screen_screen/: screenpresenter.cpp screenview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp compressedfontcache.cpp compressedunmappedfontcache.cpp font_verdana_10_4bpp_0.cpp font_verdana_19_4bpp_0.cpp font_verdana_32_4bpp_0.cpp font_verdanab_15_4bpp_0.cpp font_verdanai_15_4bpp_0.cpp font_verdanai_20_4bpp_0.cpp font_verdanai_22_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_19_4bpp.cpp kerning_verdana_32_4bpp.cpp kerning_verdanab_15_4bpp.cpp kerning_verdanai_15_4bpp.cpp kerning_verdanai_20_4bpp.cpp kerning_verdanai_22_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_19_4bpp.cpp table_verdana_32_4bpp.cpp table_verdanab_15_4bpp.cpp table_verdanai_15_4bpp.cpp table_verdanai_20_4bpp.cpp table_verdanai_22_4bpp.cpp unmappeddatafont.cpp vectorfontrendererbuffers.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_ky50_50.cpp svgdatabase.cpp
    ../touchgfx/generated/gui_generated/src/bluemap_screen/: bluemapviewbase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/images/src/__generated/: image_alternate_theme_images_backgrounds_320x240_spotlights.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/redmap_screen/: redmapviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen_screen/: screenviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
software components: CMSIS:CORE 4.3.0
